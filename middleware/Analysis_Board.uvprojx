# Keil uVision project Analysis_Board.uvprojx, settings and files
target Analysis_Board (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Analysis_Board +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c misc: --cpp
  c include: .\Libraries\CMSIS;.\Libraries\FWlib\inc;.\Libraries\FWlib\src;.\Source;.\FREAME;.\USER\main;.\USER\marvlink;.\USER;.\Source\uart;.\USER\init;.\Source\pwmout;.\Source\pwmin;.\Source\time;.\Source\da;.\Source\sys;.\USER\wp;.\USER\rc;.\Source\sonar;.\USER\flow
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ./Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group LIB
    ./Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ./USER/main/: main.cpp
    ./USER/marvlink/: marvlink.cpp
    ./USER/init/: init.cpp
    ./USER/rc/: rc.cpp
    ./USER/flow/: flow.cpp
  group SOURCE
    ./Source/uart/: USART.cpp datatransfor.cpp
    ./USER/: stm32f10x_it.c
    ./Source/pwmout/: PWMOUT.cpp
    ./Source/pwmin/: PWMIN.cpp
    ./Source/time/: delay.cpp
    ./Source/sys/: systime.cpp
    ./Source/sonar/: ultrasonic.cpp
  group CMSIS
    ./Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group doc
    ./: record.txt
